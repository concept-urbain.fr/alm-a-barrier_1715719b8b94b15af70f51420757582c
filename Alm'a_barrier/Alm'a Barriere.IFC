Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: PROTO-ALMA-BAR-V2-NEW-001.IFC
Time: 2020-05-05T06:56:00
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: ALMA-BAR-MUL-NEW-002_Default
In: Default Storey
Material: S 235

# IfcBeam: PROTO-ALMA-POT-V2-002_Default
In: Default Storey
Material: 0

# IfcBeam: Tête potelet Alma - Modèle 2_Default
In: Default Storey
Material: 0

# IfcBuildingElementProxy: ALMA-BAR-MUL-NEW-001_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: S 235

# IfcBuildingElementProxy: ALMA-BAR-MUL-NEW-003_Default
In: Default Storey
PredefinedType: ELEMENT; Material: S 235

# IfcBuildingElementProxy: PROTO-ALMA-POT-V2-002_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: TBHC-M6x12-A2_Default (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Tête potelet Alma - Modèle 2_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0
